# Keil uVision project 顶板.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: 顶板 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\lib\n76e003\Include;..\lib\user\inc
  group STARTUP
    ../lib/n76e003/Startup/: STARTUP.A51
  group COMMON
    ../lib/n76e003/Common/: Common.c Delay.c
  group LIB
    ../lib/user/: main.c
    ../lib/user/src/: func.c global.c io.c
